# On generic X86 build (which runs on virtual platforms),
# serial consoles are absent. There is no need to run
# serial-getty on those platforms.

SERIAL_CONSOLE=""
