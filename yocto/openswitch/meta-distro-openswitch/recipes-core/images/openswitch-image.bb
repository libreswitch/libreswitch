DESCRIPTION = "OpenSwitch Rootfs Image"

IMAGE_LINGUAS = " "
IMAGE_FEATURES += "read-only-rootfs ssh-server-openssh"

LICENSE = "Apache-2.0"

inherit core-image
