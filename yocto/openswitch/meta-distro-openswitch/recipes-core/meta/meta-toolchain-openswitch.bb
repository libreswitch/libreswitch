# OpenSwitch Distribution toolchain
PR = "r0"
TOOLCHAIN_TARGET_TASK = "packagegroup-ops-toolchain-target"

require recipes-core/meta/meta-toolchain.bb
