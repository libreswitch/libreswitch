# Copyright Mellanox Technologies, Ltd. 2001-2016.

EXTRA_OECMAKE += "-DSAI_VENDOR=MLNX"
