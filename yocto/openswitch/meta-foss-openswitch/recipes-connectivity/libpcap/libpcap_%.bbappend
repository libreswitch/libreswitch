# Copyright (C) 2015 Hewlett Packard Enterprise Development LP
PR_append = "_openswitch"

BBCLASSEXTEND = "native"
