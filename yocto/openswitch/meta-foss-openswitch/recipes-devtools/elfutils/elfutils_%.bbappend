# Copyright (C) 2016 Hewlett Packard Enterprise Development LP

PR_append = "_openswitch"

# makedump requires static version
DISABLE_STATIC = ""
