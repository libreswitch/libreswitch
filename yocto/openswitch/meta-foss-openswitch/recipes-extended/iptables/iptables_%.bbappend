# Copyright (C) 2015 Hewlett Packard Enterprise Development LP

PR_append = "_openswitch"

RRECOMMENDS_${PN} += "kernel-module-xt-nat \
"
