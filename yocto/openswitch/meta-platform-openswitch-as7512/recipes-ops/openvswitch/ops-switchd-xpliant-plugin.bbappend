# Copyright (C) 2016, Cavium, Inc. All Rights Reserved.

PR_append = "_as7512"

CFLAGS += "-DOPS_AS7512"
