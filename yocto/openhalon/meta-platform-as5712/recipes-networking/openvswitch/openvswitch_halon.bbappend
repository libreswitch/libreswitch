# Copyright 2015  Hewlett-Packard Development Company, L.P.

PR_append = "_as5712"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCREV = "a866c19c8"

DEPENDS += "bcmsdk"

