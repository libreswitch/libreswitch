DESCRIPTION = "Halon Rootfs Image"

IMAGE_LINGUAS = " "
IMAGE_FEATURES += "read-only-rootfs"

LICENSE = "HP"

inherit core-image
