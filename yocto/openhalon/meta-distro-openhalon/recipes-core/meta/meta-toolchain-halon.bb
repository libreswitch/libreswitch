# Halon Distribution toolchain
PR = "r0"
TOOLCHAIN_TARGET_TASK = "packagegroup-halon-toolchain-target"

require recipes-core/meta/meta-toolchain.bb
