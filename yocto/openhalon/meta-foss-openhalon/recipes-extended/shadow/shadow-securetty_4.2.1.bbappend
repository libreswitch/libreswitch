# Copyright 2013  Hewlett-Packard Development Company, L.P. 

PR_append = "_openhalon"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
            file://securetty \
"
