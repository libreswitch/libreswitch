# Copyright 2013  Hewlett-Packard Development Company, L.P. 

PR_append = "_openhalon"

RRECOMMENDS_${PN} += "kernel-module-xt-nat \
"

