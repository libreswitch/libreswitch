# Copyright 2013  Hewlett-Packard Development Company, L.P. 
PR_append = "_openhalon"

FILES_${PN} = "/usr/lib"
FILES_${PN}-dev += "/usr/bin/lttng-gen-tp"

