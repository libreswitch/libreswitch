# Copyright 2015  Hewlett-Packard Development Company, L.P. 

PR_append = "_openhalon"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
