# Copyright (C) 2015 Hewlett Packard Enterprise Development LP
PR_append = "_libreswitch"

FILES_${PN} = "/usr/lib"
FILES_${PN}-dev += "/usr/bin/lttng-gen-tp"

