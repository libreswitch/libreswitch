# Copyright (C) 2016 Hewlett Packard Enterprise Development LP

PR_append = "_libreswitch"

# Disable kdump from the initscripts, we use our own kdump setup
INITSCRIPT_PACKAGES = ""
