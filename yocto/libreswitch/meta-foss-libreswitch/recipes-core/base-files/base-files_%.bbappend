# Copyright (C) 2015 Hewlett Packard Enterprise Development LP

PR_append = "_libreswitch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

hostname = "${DISTRO_SHORTNAME}-${MACHINE}"
