require python-markupsafe.inc

RDEPENDS_${PN}_class-native = ""

inherit setuptools
