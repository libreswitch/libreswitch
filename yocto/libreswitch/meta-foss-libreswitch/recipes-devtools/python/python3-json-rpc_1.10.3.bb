inherit setuptools3
require python-json-rpc.inc
