inherit setuptools
require python-jinja2.inc
