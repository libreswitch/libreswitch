inherit setuptools3
require python-werkzeug.inc
