inherit setuptools
require python-xattr.inc
