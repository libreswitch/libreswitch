inherit setuptools
require python-werkzeug.inc
