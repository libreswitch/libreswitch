# Copyright Mellanox Technologies, Ltd. 2001-2016.

MLNX_HW_MGMT_VERSION ??= ""
MLNX_HW_MGMT_URI ??= "file://"

SX_SDK_VERSION ??= ""
SX_SDK_URI ??= "file://"
