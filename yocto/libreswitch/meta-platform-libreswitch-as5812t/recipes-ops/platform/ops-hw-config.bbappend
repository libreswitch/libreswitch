# Copyright (C) 2015 Hewlett Packard Enterprise Development LP

PR_append = "_as5812t"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PLATFORM_PATH = "Accton/AS5812-54T"
