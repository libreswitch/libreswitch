# Copyright 2013  Hewlett-Packard Development Company, L.P. 

PR_append = "_hp"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
            file://securetty \
"
