# Copyright 2013  Hewlett-Packard Development Company, L.P. 

PR_append = "_magma"

RRECOMMENDS_${PN} += "kernel-module-xt-nat \
"

